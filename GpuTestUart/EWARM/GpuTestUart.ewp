# IAR project GpuTestUart.ewp, settings and files
configuration GpuTestUart (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\Shell\Terminal\Source; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\Shell\Terminal\Cfg; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\Shell\Source; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\Shell\Cmd\General; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\Shell\Cfg; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\CPU\IAR; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\CPU; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\CPU\Cfg; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\Lib; E:\DiskE\ProgramProject\GPUTFT\uc-Micrium\Lib\Cfg; E:\DiskE\ProgramProject\GPUTFT\userCode
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: GpuTestUart.hex
  ILINK.IlinkOutputFile: GpuTestUart.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: dma.c freertos.c gpio.c main.c rtc.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group uC_Micrium/uC_CPU
    ../../uc-Micrium/CPU/IAR/: cpu.h
    ../../uc-Micrium/CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC_Micrium/uC_Lib
    ../../uc-Micrium/Lib/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uc-Micrium/Lib/Cfg/: lib_cfg.h
  group uC_Micrium/uC_Shell
    ../../uc-Micrium/Shell/Cmd/General/: sh_shell.c sh_shell.h
    ../../uc-Micrium/Shell/Source/: shell.c shell.h
    ../../uc-Micrium/Shell/Cfg/: shell_cfg.h
    ../../uc-Micrium/Shell/Terminal/Source/: terminal.c terminal.h
    ../../uc-Micrium/Shell/Terminal/Cfg/: terminal_cfg.h
    ../../uc-Micrium/Shell/Terminal/Mode/VT100/: terminal_mode.c
    ../../uc-Micrium/Shell/Terminal/OS/FreeRTOS/: terminal_os.c
    ../../uc-Micrium/Shell/Terminal/Serial/: terminal_serial.c
  group UserCode
    ../../userCode/: app_cfg.h GPU_Serial.c send_test.c shell_app.c
